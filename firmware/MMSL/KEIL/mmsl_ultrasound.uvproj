# Keil uVision project mmsl_ultrasound.uvproj, settings and files
target ultrasound (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0-0x7FFFF) CLOCK(192000000) CPUTYPE("Cortex-M4") FPU2
  output: mmsl_ultrasound +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --diag_suppress=177
  c include: ..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\M480\Include;..\..\Library\StdDriver\inc;..\..\ThirdParty\uip-0.9\uip;..\..\ThirdParty\uip-0.9\unix;..\..\ThirdParty\uip-0.9\apps\httpd;..\..\MMSL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group system
    ../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group mmsl
    ../: main.c webserver.c dependencies.c
    ./: mcu_display_control.c
  group lib
    ../../Library/StdDriver/src/: clk.c emac.c gpio.c sys.c timer.c uart.c retarget.c
  group uIP
    ../../ThirdParty/uip-0.9/uip/: uip.c uip_arp.c
    ../../ThirdParty/uip-0.9/unix/: uip_arch.c
